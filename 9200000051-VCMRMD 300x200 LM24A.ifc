Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-05-06T08:18:06
Written by: ODA IFC SDK 22.8
Made in: 22.1.21.13 - Exporter 22.1.21.13 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_930781 | SINK
Port_930781 | SOURCE

# IfcFlowController: NLRS_57_DUA_UN_rectangular-constant-volume-damper-vcmr_sacs:Double wall, NLRS_57_DUA_UN_rectangular-constant-volume-damper-vcmr_sacs:Double wall:930781
In: Default
Type - Description: Rectangular Volume Damper VCMR; PredefinedType: CONTROLDAMPER; Classification: 57.00 (Uniformat); Material: NLRS_A_SACS_SVZ
Type - Constraints - Default Elevation: 0 mm
Type - General - Product_Data: VCMR_Data
Type - Identity Data - Assembly Code: 57.00; Description: Rectangular Volume Damper VCMR; Manufacturer: Solid Air Climate Solutions; Model: Constant volume damper - Rectangular; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 02-05-2022; NLRS_C_content_provider: Solid Air Climate Systems; NLRS_C_content_versie: Versie 3.19.00; NLRS_C_description: Rectangular Volume Damper VCMR; NLRS_C_niveau ontwikkeling: LOD400; Type Comments: Check flow direction!; Type Name: Double wall; URL: https://solid-air.nl/pcategorie/volumeregelaar/
Type - Other - Category: Duct Accessories; Family Name: NLRS_57_DUA_UN_rectangular-constant-volume-damper-vcmr_sacs
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Type - Pset_ProductRequirements - Category: Duct Accessories
Material: Belimo_Grey, NLRS_A_SACS_SVZ
Pset_DistributionFlowElementCommon - Reference: Double wall; sets with these values: 2
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.537168 m2; NLRS_C_lengte: 350 mm; NLRS_M_c01_breedte: 300 mm; NLRS_M_c01_hoogte: 200 mm; SACS_Duct_Height: 200 mm; SACS_Duct_Width: 300 mm; Size: 300x200-300x200; Volume: 0.00053056 m3
Graphics - Use Annotation Scale: no
Identity Data - Mark: 306; NLRS_C_model: VCMRMD 300x200 LM24A; SACS_Article_Code: 9200000051; SACS_Gross_Cost: 616; SACS_Price_Date: 01-02-2022
Insulation - Insulation Thickness: 0 mm; Overall Size: 300 mmx200 mm-300 mmx200 mm
Lining - Free Size: 300 mmx200 mm-300 mmx200 mm; Lining Thickness: 0 mm
Mechanical - System Classification: Undefined
Mechanical - Flow - Advised minimal air velocity: 4 m/s; Minimal required ▲P over damper: 50 Pa; NLRS_M_c01_debiet: 0 m3/s; NLRS_M_c01_drukverlies_statisch: 50 Pa; Pressure Drop: 0 Pa; SACS_Air_Velocity: 0 m/s
Model Properties - Control type (0-2): 1; SACS_Option_1: 24 volt, 2positions; SACS_Option_2: Double wall
Other - Family: NLRS_57_DUA_UN_rectangular-constant-volume-damper-vcmr_sacs; Family and Type: NLRS_57_DUA_UN_rectangular-constant-volume-damper-vcmr_sacs: Double wall; Type: Double wall; Type Id: 929096
Phasing - Phase Created: New Construction
Text - SACS_Warning_Text_Flow: Airflow below advised 4m/s
Visibility - SACS_Disable_Warning: yes; Show_recommended_placement_zone: yes
